## tagger/main/Kconfig.projbuild
```kconfig
menu "Tagger Configuration"

    config FOO
        string "The Foo"
        default "the foo string"
        help
            whatever

endmenu
```
